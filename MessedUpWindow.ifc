Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: MessedUpWindow.ifc
Time: 2024-12-15T16:58:04+00:00
Organization: n/a, n/a
Written by: IfcOpenShell 0.8.1-alpha241201
Made in: Bonsai 0.8.1-alpha241201-1ecf722
Authorization: Nobody

# IfcGroup (4)
Name | Description
Proposed | {"type": "BBIM_Search", "query": "IfcTypeProduct, IfcProduct, \"EPset_Status\".\"Status\" = \"NEW\""}
Demolish | {"type": "BBIM_Search", "query": "IfcTypeProduct, IfcProduct, \"EPset_Status\".\"Status\" = \"DEMOLISH\""}
Existing | {"type": "BBIM_Search", "query": "IfcTypeProduct, IfcProduct, \"EPset_Status\".\"Status\" = \"EXISTING\""}
ProposedGroundFloor | {"type": "BBIM_Search", "query": "IfcTypeProduct, IfcProduct, \"EPset_Status\".\"Status\" = /NEW/EXISTING/, location=\"MC-01-Ground\""}

# IfcOpeningElement (11)
Name | In
3 x Opening | PredefinedType: OPENING
7x12cutout | MC-03-Roof
3 x 12x12cutout | MC-03-Roof
4 x Opening | MC-03-Roof

# IfcRoof, Existing Roof
In: MC-03-Roof
PredefinedType: GABLE_ROOF; Group: ProposedGroundFloor
BBIM_Boolean - Data: [190892]
BBIM_Roof - Data: {"roof_type": "HIP/GABLE ROOF", "generation_method": "ANGLE", "roof_thickness": 40.00000283122063, "rafter_edge_angle": 1.5707963705062866, "angle": 0.6283185482025146, "percentage": 72.65425872802734, "path_data": {"edges": [[0, 1], [1, 2], [2, 3], [3, 0]], "verts": [[-1276.99365234375, 599.9993896484375, 0.0], [-1276.99365234375, 18924.794921875, 0.0], [5986.998046875, 18924.794921875, 0.0], [5986.998046875, 599.9993896484375, 0.0]], "gable_roof_angles": [0.0, 1.5707963705062866, 0.0, 1.5707963705062866], "gable_roof_separate_verts": [0, 1, 0, 1]}}
EPset_Status - Status: DEMOLISH

# IfcWindow: WT05 1200x1200 Velux (3)
In: MC-03-Roof
Type - PredefinedType: SKYLIGHT; PartitioningType: SINGLE_PANEL
Type - BBIM_Window - Data: {"window_type": "SINGLE_PANEL", "overall_height": 1200.0000476837158, "overall_width": 1200.0000476837158, "lining_properties": {"lining_depth": 200.00000298023224, "lining_thickness": 50.00000074505806, "lining_offset": -25.00000037252903, "lining_to_panel_offset_x": 50.00000074505806, "lining_to_panel_offset_y": -170.00000178813934}, "panel_properties": {"frame_depth": [24.99999237060547, 34.999996185302734, 34.999996185302734], "frame_thickness": [14.999991416931152, 34.999996185302734, 34.999996185302734]}}
OverallHeight: 1200 mm; OverallWidth: 1200 mm
EPset_Status - Status: DEMOLISH

# IfcWindow: WT05 750x1200 Velux, Window
In: MC-03-Roof
Type - PredefinedType: SKYLIGHT; PartitioningType: SINGLE_PANEL
Type - BBIM_Window - Data: {"window_type": "SINGLE_PANEL", "overall_height": 1200.0000476837158, "overall_width": 750.0000596046448, "lining_properties": {"lining_depth": 200.00000298023224, "lining_thickness": 50.00000074505806, "lining_offset": -25.00000037252903, "lining_to_panel_offset_x": 50.00000074505806, "lining_to_panel_offset_y": -170.00000178813934}, "panel_properties": {"frame_depth": [24.9999942779541, 34.999996185302734, 34.999996185302734], "frame_thickness": [14.999992370605469, 34.999996185302734, 34.999996185302734]}}
OverallHeight: 1200 mm; OverallWidth: 750 mm
EPset_Status - Status: DEMOLISH
